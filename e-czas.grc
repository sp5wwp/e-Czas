options:
  parameters:
    author: Wojciech Kaczmarski SP5WWP
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: eczas
    output_language: python
    title: e-Czas signal processor
  states: {}

blocks:
- name: carrier
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: deviation
  id: variable
  parameters:
    value: 36/(360*0.019)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.01'
    decay_rate: '0.01'
    gain: '1.0'
    max_gain: '10'
    reference: 1.0/math.sqrt(2.0)
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2.0*math.pi*deviation)
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: '"hw:0,0"'
    samp_rate: '48000'
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '10'
    high_cutoff_freq: carrier+50+10
    low_cutoff_freq: carrier-50-10
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: carrier+50+10
    low_cutoff_freq: carrier-50-10
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(samp_rate/10/2)
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/fifo1
    type: short
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '32767.0'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(samp_rate/10)
    max_iter: '4000'
    scale: 1/int(samp_rate/10)
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: bypassed}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: ../dump.wav
    format: FORMAT_WAV
    samp_rate: '500'
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: samples/224k_1836.wav
    repeat: 'False'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '101'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '50.0'
    decim: '96'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '5.0'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    legend: 'False'
    type: float
    ymax: '0'
  states: {state: disabled}
- name: qtgui_tab_widget
  id: qtgui_tab_widget
  parameters:
    label0: Input monitor
    label1: AGC output
    label2: Output
    num_tabs: '3'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: qtgui_tab_widget@0
    legend: 'False'
    size: '960'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: qtgui_tab_widget@1
    legend: 'False'
    size: '960'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: qtgui_tab_widget@2
    legend: 'False'
    size: '1500'
    srate: '500'
    tr_delay: 0.0005*500
    tr_level: '-0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_slope: qtgui.TRIG_SLOPE_NEG
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    int_max: '0'
    type: float
  states: {state: disabled}

connections:
- [analog_agc2_xx_0, '0', band_pass_filter_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_delay_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_moving_average_xx_0, '0']
- [audio_source_0, '0', band_pass_filter_0, '0']
- [audio_source_0, '0', qtgui_time_sink_x_0, '0']
- [band_pass_filter_0, '0', analog_agc2_xx_0, '0']
- [band_pass_filter_0_0, '0', hilbert_fc_0, '0']
- [band_pass_filter_0_0, '0', qtgui_freq_sink_x_0, '0']
- [band_pass_filter_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [band_pass_filter_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_delay_0, '0', blocks_sub_xx_0, '0']
- [blocks_float_to_short_0, '0', blocks_file_sink_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_sub_xx_0, '1']
- [blocks_sub_xx_0, '0', low_pass_filter_0, '0']
- [blocks_throttle2_0, '0', band_pass_filter_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']
- [hilbert_fc_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', blocks_float_to_short_0, '0']
- [low_pass_filter_0, '0', blocks_wavfile_sink_0_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
